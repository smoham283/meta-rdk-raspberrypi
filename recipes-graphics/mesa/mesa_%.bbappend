RDEPENDS_${PN}-dev = " \
    libegl-mesa-dev \
    libgl-mesa-dev \
    libglapi-dev \
    libgbm-dev \
    libgles1-mesa-dev \
    libgles2-mesa-dev \
    libgles3-mesa-dev \
    "
